DESCRIPTION = "Prompting monad that allows splitting the description of a computation from the implementation of the effects used in that computation."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=11c73a8952ae0da947602633c0897ef8"

HPN = "MonadPrompt"
inherit hackage

SRC_URI[md5sum] = "d3dfccfcb90d6242cd151fcd49d143cf"
SRC_URI[sha256sum] = "b012cbbe83650f741c7b7f6eafcc89dec299b0ac74a758b6f3a8cdfc5d3bbeda"

PR = "r1"
