DESCRIPTION = "Fast and efficient encoding and decoding of base64-encoded strings."
LICENSE = "BSD3"
LIC_FILES_CHKSUM="file://LICENSE;md5=5c600bfc7377e36f0fb87990f96821e5"

inherit hackage

SRC_URI[md5sum] = "e6e646d1a452f6626de0dd09c8bdbd6b"
SRC_URI[sha256sum] = "fbf8ed30edde271eb605352021431d8f1b055f95a56af31fe2eacf6bdfdc49c9"
