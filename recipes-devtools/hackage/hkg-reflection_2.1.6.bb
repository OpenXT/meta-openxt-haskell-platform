DESCRIPTION = ""
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=34054afc68437c9d322fe9d9fcef8870"

inherit hackage

SRC_URI[md5sum] = "6ca3398fb7607877f83a2a8dd9d6707b"
SRC_URI[sha256sum] = "bf3e14917ebb329a53701a3cce0afe670f20037a0148dbfa5cbfa574ed6ba6cd"

PR = "r1"
