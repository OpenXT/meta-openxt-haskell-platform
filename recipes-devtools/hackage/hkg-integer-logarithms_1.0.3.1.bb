DESCRIPTION = ""
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d02c4347289a9326f8de6e031a6a171e"

inherit hackage

SRC_URI[md5sum] = "15bccece342fcf3699e0f48bc0e864b3"
SRC_URI[sha256sum] = "9b0a9f9fab609b15cd015865721fb05f744a1bc77ae92fd133872de528bbea7f"

PR = "r1"
