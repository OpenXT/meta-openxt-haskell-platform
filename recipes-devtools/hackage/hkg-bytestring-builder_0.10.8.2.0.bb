DESCRIPTION = ""
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b4fb43cd0f1e9b579b9b67b76d3857c4"

inherit hackage

SRC_URI[md5sum] = "bd23c173b363091b3677f9ec6d620968"
SRC_URI[sha256sum] = "27faef6db27c5be5a3715fd68b93725853e0e668849eaf92ce7c33cef9cb2c3f"

PR = "r1"
