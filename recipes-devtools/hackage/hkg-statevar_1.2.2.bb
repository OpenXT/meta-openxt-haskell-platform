DESCRIPTION = ""
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=eff8563aaa3722b59b6cd8818b4a8d9d"

inherit hackage

SRC_URI[md5sum] = "f8eef62fbd91e14eceee6e1a5cc8bc1c"
SRC_URI[sha256sum] = "5e4b39da395656a59827b0280508aafdc70335798b50e5d6fd52596026251825"

HPN = "StateVar"
PR = "r1"
