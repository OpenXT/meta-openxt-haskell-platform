DESCRIPTION = ""
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=30f0d024ae4c6feef6c4123a11c7a49f"

inherit hackage

SRC_URI[md5sum] = "6662b26a3afb0a12cf5a1cae217e1e23"
SRC_URI[sha256sum] = "d8f97ac14ab47b6b8a7b0fdb4ff95426322ec56badd01652ac15da4a44d4bab8"

PR = "r1"
