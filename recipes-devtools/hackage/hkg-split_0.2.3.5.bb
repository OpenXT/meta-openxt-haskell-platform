DESCRIPTION = "A collection of various methods for splitting lists into parts, akin to the "split" function found in several mainstream languages."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=6994c17380b45ebadfe3efa7507ad3da"

inherit hackage

SRC_URI[md5sum] = "3426ff2a7f64549f4c2628b246e18a19"
SRC_URI[sha256sum] = "bf8aa8d610354a2b576946a6c838251ec5988c8374100638e6b2604513b93159"
