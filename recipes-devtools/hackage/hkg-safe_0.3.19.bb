DESCRIPTION = "A library wrapping Prelude/Data.List functions that can throw exceptions, such as head and !!."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e06a64301a374337cef050092cfda9a4"

inherit hackage

SRC_URI[md5sum] = "23a1bcc16b885249dc35370b1c428cc7"
SRC_URI[sha256sum] = "25043442c8f8aa95955bb17467d023630632b961aaa61e807e325d9b2c33f7a2"

PR = "r1"
