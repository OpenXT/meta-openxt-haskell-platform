DESCRIPTION = ""
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=7bd5b9bd1eb743b2fef83af75de60046"

inherit hackage

SRC_URI[md5sum] = "70f217bdea5b2fac923b0b0f638f7b62"
SRC_URI[sha256sum] = "6d065402394e7a9117093dbb4530a21342c9b1e2ec509516c8a8d0ffed98ecaa"

PR = "r1"
