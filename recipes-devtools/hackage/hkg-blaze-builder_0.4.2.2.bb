DESCRIPTION = ""
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=1381508276b4a17c8568a61e8e34282d"

inherit hackage

SRC_URI[md5sum] = "3b408abaf6b70212f906ecf8c1a07e3a"
SRC_URI[sha256sum] = "2cdc998c021d3a5f2a66a95138b93386271c26a117e7676d78264a90e536af67"

PR = "r1"
