SUMMARY = "A UTF8 layer for IO and Strings."
DESCRIPTION = "The utf8-string package provides operations for encoding UTF8 strings to Word8 lists and back, and for reading and writing UTF8 without truncation."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=8061b32e50a7a7433f0c7bd9f431ca96"

inherit hackage

SRC_URI[md5sum] = "15d21b4c87fa3fd1ee73b4fc5b2b322c"
SRC_URI[sha256sum] = "ee48deada7600370728c4156cb002441de770d0121ae33a68139a9ed9c19b09a"

PR = "r1"
