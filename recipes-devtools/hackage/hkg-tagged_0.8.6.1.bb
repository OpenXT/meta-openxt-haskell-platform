DESCRIPTION = ""
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=6642f8d529de7903fd72440c2a7d230f"

inherit hackage

SRC_URI[md5sum] = "3fd62558bfc3f5ca1b93f0c0d54f1196"
SRC_URI[sha256sum] = "f5e0fcf95f0bb4aa63f428f2c01955a41ea1a42cfcf39145ed631f59a9616c02"

PR = "r1"
