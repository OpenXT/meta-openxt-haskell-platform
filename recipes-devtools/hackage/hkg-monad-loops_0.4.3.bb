DESCRIPTION = "Some useful control operators for looping."
LICENSE = "GPL-2.0"
LIC_FILES_CHKSUM="file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

inherit hackage

SRC_URI[md5sum] = "e590aa3f2de078eba409723eceed153a"
SRC_URI[sha256sum] = "7eaaaf6bc43661e9e86e310ff8c56fbea16eb6bf13c31a2e28103138ac164c18"

PR = "r1"
