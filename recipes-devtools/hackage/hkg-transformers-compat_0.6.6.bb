DESCRIPTION = "This package provides backported types added to older versions of transformers."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d554ded64d0703b2a5e00cefaac75525"

inherit hackage

SRC_URI[md5sum] = "21cfd203ebdc7c91739f06d36b5fa7da"
SRC_URI[sha256sum] = "7e2e0251e5e6d28142615a4b950a3fabac9c0b7804b1ec4a4ae985f19519a9f9"

PR = "r1"
