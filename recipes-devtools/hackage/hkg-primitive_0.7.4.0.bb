DESCRIPTION = ""
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=be0b31f4d3a51d26d9983b09dc5cf70a"

inherit hackage

SRC_URI[md5sum] = "395db1c6b4798fe4c01daa1a28fa8fdd"
SRC_URI[sha256sum] = "5b2d6dc2812eb2f6a115f05fcbe3e723d3aeff7894b012c617e075130581add5"

PR = "r1"
