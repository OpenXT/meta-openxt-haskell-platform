DESCRIPTION = ""
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=84c43960ac46d7029410756642d4da01"

inherit hackage

SRC_URI[md5sum] = "62eb3c78a01d7545551f7961ec5f2340"
SRC_URI[sha256sum] = "53af758ddc37dc63981671e503438d02c6f64a2d8744e9bec557a894431f7317"

PR = "r1"
