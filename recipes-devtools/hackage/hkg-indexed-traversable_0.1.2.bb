DESCRIPTION = ""
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d17cf045ce59697fc2ae811b58fb5f5f"

inherit hackage

SRC_URI[md5sum] = "4213af572c592a9a21e73bf3d376c362"
SRC_URI[sha256sum] = "516858ee7198b1fed1b93c665157f9855fd947379db7f115d48c1b0d670e698d"

PR = "r1"
