DESCRIPTION = "This package provides a low-level networking interface."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=78dd98be72709820ee0098ba6a71a888"

inherit hackage

SRC_URI[md5sum] = "f32e287c9957b6605da3dd677182cb68"
SRC_URI[sha256sum] = "7f7620fef1a1af3d3d6747f510e73223a5c600e7d7fd9ace073d1222bdc63d85"

PR = "r1"
