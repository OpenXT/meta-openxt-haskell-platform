DESCRIPTION = ""
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=da5bccb37741b38b68ab236dec15b1f2"

inherit hackage

SRC_URI[md5sum] = "9843db6ba76ec533276f3a304bb2fa3b"
SRC_URI[sha256sum] = "66e3c0b4e2d32287621a3faab6b99c7e03b285a07711f335332aec6b4217bf8b"

PR = "r1"
