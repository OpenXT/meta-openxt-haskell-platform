DESCRIPTION = "This library provides FFI bindings to syslog(3) from POSIX.1-2008."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=5e6c932b646ccd55858ca0f522bbd186"

inherit hackage

SRC_URI[md5sum] = "06935f5a83ac5c4f3683c71a1f6e1121"
SRC_URI[sha256sum] = "3eec43c8fb42c23d03f1db7b0b594d39cd94275c2284dcd0c64aa4d680bd7ece"

PR = "r1"
