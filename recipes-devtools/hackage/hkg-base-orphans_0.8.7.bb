DESCRIPTION = ""
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c4629488e71a17f8111226552f50e9c3"

inherit hackage

SRC_URI[md5sum] = "2de94883af146822e5a4b74539568955"
SRC_URI[sha256sum] = "888fd67f0dbe932778f5b170922ce80d0dcab1680ee98f1d6fcc362f20d9e447"

PR = "r1"
