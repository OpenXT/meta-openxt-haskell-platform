DESCRIPTION = "A binary serialization library, similar to binary, that introduces an isolate primitive for parser isolation, and labeled blocks for better error messages."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=5ec64b8b2cb5d58bfa9e4662374b9108"

inherit hackage

SRC_URI[md5sum] = "1096cadb75871acc0eeb0630ff6aa39e"
SRC_URI[sha256sum] = "99905220661b26e5bd91130bd9772554938608a5b1d717240a6eb331121e0f6a"

PR = "r1"
