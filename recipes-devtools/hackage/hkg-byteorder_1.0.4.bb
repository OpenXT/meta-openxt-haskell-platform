DESCRIPTION = "This package is for working with the native byte-ordering of the system."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=7bfb975591c3d1d9370d2450eb251342"

inherit hackage

SRC_URI[md5sum] = "a68226a369ffae7f344d6f21d2827439"
SRC_URI[sha256sum] = "bd20bbb586947f99c38a4c93d9d0266f49f6fc581767b51ba568f6d5d52d2919"

PR = "r1"
