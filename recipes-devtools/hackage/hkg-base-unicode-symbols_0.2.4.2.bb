DESCRIPTION = "This package defines new symbols for a number of functions, operators and types in the base package."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=25bddfc5e532da29a728b77447044272"

inherit hackage

SRC_URI[md5sum] = "8f6bf2b5f9dd94d3d8913e770c3989d3"
SRC_URI[sha256sum] = "4364d6c403616e9ec0c240c4cb450c66af43ea8483d73c315e96f4ba3cb97062"

PR = "r1"
