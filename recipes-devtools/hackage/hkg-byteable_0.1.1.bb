DESCRIPTION = ""
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=82b3e215c1ce96685c1e8295e33b0bb1"

inherit hackage

SRC_URI[md5sum] = "ebe2d61954382fcfe3be483951d8a77b"
SRC_URI[sha256sum] = "243b34a1b5b64b39e39fe58f75c18f6cad5b668b10cabcd86816cbde27783fe2"

PR = "r1"
