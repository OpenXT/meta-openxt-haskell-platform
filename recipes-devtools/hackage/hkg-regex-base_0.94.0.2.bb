DESCRIPTION = "Interface API for regex-posix,pcre,parsec,tdfa,dfa."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a583c2fab876948127b9e9a2ca06634c"

inherit hackage

SRC_URI[md5sum] = "992d44dc9748288ce900cc197d6c0883"
SRC_URI[sha256sum] = "7b99408f580f5bb67a1c413e0bc735886608251331ad36322020f2169aea2ef1"

PR = "r1"
